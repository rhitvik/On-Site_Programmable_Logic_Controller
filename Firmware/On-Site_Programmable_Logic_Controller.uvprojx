# Keil uVision project On-Site_Programmable_Logic_Controller.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C1230H6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: On-Site_Programmable_Logic_Controller
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: delay.c delay.h lcd.c lcd.h main.c rotaryencoder.c rotaryencoder.h systemclock.c systemclock.h led.h led.c pushbutton.c pushbutton.h key.h ral.h ral.c periodicTimer.c adc.c OneShotTimer.c timers.h adc.h cpuTemperature.c coretemp.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.1
